options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: R_HackRF
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: delta_f_ppm
  id: variable_qtgui_range
  parameters:
    start: '-50'
    step: '0.001'
    stop: '50'
    value: '0'
  states: {}
- name: freq_cent
  id: variable
  parameters:
    value: '440000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: variable_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: variable_gain_BB
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '62'
    value: '40'
  states: {}
- name: variable_gain_FI
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '30'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: delta_f_ppm*1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: delta_f_ppm*1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: int(15e3)
    decim: dec
    gain: variable_gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/dec
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: freq_cent+delta_f_ppm*1e6
    gain: variable_gain_FI
    samp_rate: samp_rate
    type: fc32
    vga: variable_gain_BB
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_null_sink_1, '0']
- [low_pass_filter_1, '0', blocks_moving_average_xx_0, '0']
- [low_pass_filter_1, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_1, '0', dc_blocker_xx_0, '0']
- [soapy_hackrf_source_0, '0', low_pass_filter_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
