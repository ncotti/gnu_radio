options:
  parameters:
    author: cotti
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: '-30e3'
    step: '500'
    stop: 30e3
    value: '0'
  states: {}
- name: center_freq_Ant
  id: variable_qtgui_range
  parameters:
    start: 420e6
    step: 50e3
    stop: 450e6
    value: 435e6
  states: {}
- name: decimation_factor
  id: variable
  parameters:
    value: '9'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 435e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '5'
    stop: '60'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: samp_rate_decimated
  id: variable
  parameters:
    value: samp_rate/decimation_factor
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 100e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '1000'
    rate: '1e-4'
    reference: '0.9'
    type: complex
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: samp_rate_decimated
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_freq
    decim: decimation_factor
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_decimated
    fc: '0'
    fftsize: '1024'
    name: FI
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: Antenna frequency
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '9'
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq_Ant
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_rcv_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
