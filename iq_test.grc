options:
  parameters:
    author: cotti
    generate_options: qt_gui
    id: iq_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: iqbalance_fix_cc_0
  id: iqbalance_fix_cc
  parameters:
    mag: '1'
    phase: '1'
  states: {}
- name: iqbalance_optimize_c_0
  id: iqbalance_optimize_c
  parameters:
    period: '1'
  states: {}

connections:
- [analog_const_source_x_0, '0', iqbalance_fix_cc_0, '0']
- [analog_const_source_x_0, '0', iqbalance_optimize_c_0, '0']
- [iqbalance_fix_cc_0, '0', blocks_null_sink_0, '0']
- [iqbalance_optimize_c_0, iqbal_corr, iqbalance_fix_cc_0, iqbal_corr]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
