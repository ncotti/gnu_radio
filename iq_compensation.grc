options:
  parameters:
    author: Nicolas G. Cotti
    copyright: GNU GPL v3.0
    description: Demonstration of the IQ imbalance compensation algorithm
    gen_cmake: 'Off'
    generate_options: hb
    id: IQ_Compensation
    output_language: python
    title: IQ Compensation
  states: {}

blocks:
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_2
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_3
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_divide_xx_3_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_divide_xx_4
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: symbol_qtty
    max_iter: symbol_qtty
    scale: 1/symbol_qtty
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_0
  id: blocks_moving_average_xx
  parameters:
    length: symbol_qtty
    max_iter: symbol_qtty
    scale: 1/symbol_qtty
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_0_0
  id: blocks_moving_average_xx
  parameters:
    length: symbol_qtty
    max_iter: symbol_qtty
    scale: 1/symbol_qtty
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_0_1
  id: blocks_moving_average_xx
  parameters:
    length: symbol_qtty
    max_iter: symbol_qtty
    scale: 1/symbol_qtty
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_1
  id: blocks_moving_average_xx
  parameters:
    length: symbol_qtty
    max_iter: symbol_qtty
    scale: 1/symbol_qtty
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: blocks_transcendental_0_0
  id: blocks_transcendental
  parameters:
    name: asin
    type: float
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: Theta parameters
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: C coefficients
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: Remove DC offset
  states: {}
- name: note_0_1_1_0
  id: note
  parameters:
    note: Receive and balance
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: g_rx
    optional: 'True'
    type: float
  states: {state: disabled}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: phi_rx
    optional: 'True'
    type: float
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: symbol_qtty
  id: parameter
  parameters:
    label: N
    type: complex
    value: '1024'
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: theta_2
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: theta_1
  states: {}
- name: virtual_sink_3_1
  id: virtual_sink
  parameters:
    stream_id: theta_3
  states: {}
- name: virtual_sink_3_1_0
  id: virtual_sink
  parameters:
    stream_id: c_1
  states: {}
- name: virtual_sink_3_1_0_0
  id: virtual_sink
  parameters:
    stream_id: c_2
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: z_i
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: z_q
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: z_i
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: z_q
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: z_i
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: z_q
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: theta_1
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: theta_2
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: theta_2
  states: {}
- name: virtual_source_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: theta_2
  states: {state: disabled}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: theta_1
  states: {}
- name: virtual_source_2_1_0
  id: virtual_source
  parameters:
    stream_id: theta_3
  states: {}
- name: virtual_source_2_1_0_0
  id: virtual_source
  parameters:
    stream_id: theta_3
  states: {state: disabled}
- name: virtual_source_2_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: theta_3
  states: {state: disabled}
- name: virtual_source_2_1_1
  id: virtual_source
  parameters:
    stream_id: theta_1
  states: {state: disabled}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: c_1
  states: {}
- name: virtual_source_6_0
  id: virtual_source
  parameters:
    stream_id: c_2
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: z_i
  states: {}
- name: virtual_source_7_0
  id: virtual_source
  parameters:
    stream_id: z_q
  states: {}

connections:
- [blocks_abs_xx_0, '0', blocks_moving_average_xx_0_1_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_abs_xx_0_1, '0', blocks_moving_average_xx_0_1_0_1, '0']
- [blocks_add_xx_2, '0', blocks_divide_xx_4, '0']
- [blocks_complex_to_imag_0, '0', blocks_moving_average_xx_0_1_1, '0']
- [blocks_complex_to_imag_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_complex_to_real_0, '0', blocks_sub_xx_0, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_divide_xx_1, '0', virtual_sink_3_1_0, '0']
- [blocks_divide_xx_2, '0', virtual_sink_3_1_0_0, '0']
- [blocks_divide_xx_3, '0', pad_sink_1, '0']
- [blocks_divide_xx_3_0, '0', blocks_transcendental_0_0, '0']
- [blocks_divide_xx_4, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_sub_xx_0, '1']
- [blocks_moving_average_xx_0_1_0, '0', virtual_sink_3, '0']
- [blocks_moving_average_xx_0_1_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_moving_average_xx_0_1_0_1, '0', virtual_sink_3_1, '0']
- [blocks_moving_average_xx_0_1_1, '0', blocks_sub_xx_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_3_0, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0_1_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_sub_xx_1, '0']
- [blocks_multiply_xx_1_0, '0', blocks_sub_xx_1, '1']
- [blocks_multiply_xx_3, '0', blocks_add_xx_2, '0']
- [blocks_sub_xx_0, '0', virtual_sink_4, '0']
- [blocks_sub_xx_0_0, '0', virtual_sink_4_0, '0']
- [blocks_sub_xx_1, '0', blocks_transcendental_0, '0']
- [blocks_transcendental_0, '0', blocks_divide_xx_2, '0']
- [blocks_transcendental_0_0, '0', pad_sink_2, '0']
- [pad_source_0, '0', blocks_complex_to_imag_0, '0']
- [pad_source_0, '0', blocks_complex_to_real_0, '0']
- [virtual_source_1, '0', blocks_abs_xx_0, '0']
- [virtual_source_1_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_1_0_0, '0', blocks_abs_xx_0_0, '0']
- [virtual_source_1_0_0, '0', blocks_divide_xx_0, '0']
- [virtual_source_1_1, '0', blocks_abs_xx_0_1, '0']
- [virtual_source_2, '0', blocks_divide_xx_1, '0']
- [virtual_source_2_0, '0', blocks_divide_xx_1, '1']
- [virtual_source_2_0_0, '0', blocks_divide_xx_2, '1']
- [virtual_source_2_0_0_0, '0', blocks_divide_xx_3, '1']
- [virtual_source_2_1, '0', blocks_multiply_xx_1_0, '0']
- [virtual_source_2_1, '0', blocks_multiply_xx_1_0, '1']
- [virtual_source_2_1_0, '0', blocks_multiply_xx_1, '0']
- [virtual_source_2_1_0, '0', blocks_multiply_xx_1, '1']
- [virtual_source_2_1_0_0, '0', blocks_divide_xx_3, '0']
- [virtual_source_2_1_0_0_0, '0', blocks_divide_xx_3_0, '1']
- [virtual_source_2_1_1, '0', blocks_divide_xx_3_0, '0']
- [virtual_source_6, '0', blocks_multiply_xx_3, '1']
- [virtual_source_6_0, '0', blocks_divide_xx_4, '1']
- [virtual_source_7, '0', blocks_float_to_complex_0, '0']
- [virtual_source_7, '0', blocks_multiply_xx_3, '0']
- [virtual_source_7_0, '0', blocks_add_xx_2, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
