options:
  parameters:
    author: Nicolas G. Cotti
    description: Demonstration of the IQ imbalance compensation algorithm
    generate_options: qt_gui
    id: test
    output_language: python
    title: IQ compensation
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    comment: N can't be modified during the simulation
    value: '2048'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '0'
    type: 16qam
  states: {}
- name: dc_offset_i
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 0, 1, 1]'
    label: DC Offset I
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: dc_offset_q
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 1, 1, 1]'
    label: DC Offset Q
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: gain_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1, 0, 1, 1]'
    label: g
    start: '0.1'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: phase_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1, 1, 1, 1]'
    label: phi
    start: '-90'
    step: '1'
    stop: '90'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sigma
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2, 0, 1, 2]'
    label: sigma
    start: '0'
    step: '0.01'
    stop: '200e-3'
    value: '10e-3'
  states: {}
- name: IQ_Compensation_0
  id: IQ_Compensation
  parameters:
    symbol_qtty: N
  states: {}
- name: IQ_channel_0
  id: IQ_channel
  parameters:
    dc_offset_i: dc_offset_i
    dc_offset_q: dc_offset_q
    gain_offset: gain_offset
    phase_offset: phase_offset
    sigma: sigma
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '16'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constellation
  states: {}
- name: note_0_1_1
  id: note
  parameters:
    note: Transmit signal
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color2: '"black"'
    grid: 'True'
    gui_hint: '[3, 0, 5, 1]'
    label1: Reference Constellation
    label2: Received Data r
    marker1: '2'
    name: Balanced signal
    nconnections: '2'
    size: N
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[3, 1, 5, 1]'
    label1: Reference Constellation
    label2: Received data Z
    marker1: '2'
    name: Received signal with offset
    nconnections: '2'
    size: N
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: constellation
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: bytes_in
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: constellation
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: constellation
  states: {}

connections:
- [IQ_Compensation_0, '0', qtgui_const_sink_x_0, '1']
- [IQ_channel_0, '0', IQ_Compensation_0, '0']
- [IQ_channel_0, '0', qtgui_const_sink_x_0_0, '1']
- [analog_random_uniform_source_x_0, '0', digital_constellation_encoder_bc_0, '0']
- [analog_random_uniform_source_x_0, '0', virtual_sink_5, '0']
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [digital_constellation_encoder_bc_0, '0', IQ_channel_0, '0']
- [digital_constellation_encoder_bc_0, '0', virtual_sink_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
