options:
  parameters:
    author: Nicolas G. Cotti
    description: IQ channel modelization
    generate_options: hb
    id: IQ_channel
    output_language: python
    title: IQ Channel
  states: {}

blocks:
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: phase_offset
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: phase_offset
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: sigma
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: dc_offset_i
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: dc_offset_q
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_offset
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 3.1416/180
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 3.1416/180
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1*gain_offset'
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_transcendental_1
  id: blocks_transcendental
  parameters:
    name: cos
    type: float
  states: {}
- name: blocks_transcendental_1_0
  id: blocks_transcendental
  parameters:
    name: sin
    type: float
  states: {}
- name: dc_offset_i
  id: parameter
  parameters:
    label: Dc offset I
    type: eng_float
    value: '0'
  states: {}
- name: dc_offset_q
  id: parameter
  parameters:
    label: Dc offset Q
    type: eng_float
    value: '0'
  states: {}
- name: gain_offset
  id: parameter
  parameters:
    label: Gain_offset
    type: eng_float
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: phase_offset
  id: parameter
  parameters:
    label: Phase Offset
    type: eng_float
    value: '0'
  states: {}
- name: sigma
  id: parameter
  parameters:
    label: Sigma
    type: eng_float
    value: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: r_i
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r_q
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: r_i
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: r_q
  states: {}
- name: virtual_source_3_1
  id: virtual_source
  parameters:
    stream_id: r_i
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [analog_const_source_x_0_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_1, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_float_to_complex_0, '1']
- [blocks_add_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_1, '0', blocks_add_const_vxx_1_0, '0']
- [blocks_complex_to_imag_0, '0', virtual_sink_0_0, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_xx_2, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_transcendental_1, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_transcendental_1_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', blocks_multiply_xx_2_0, '1']
- [blocks_multiply_xx_2, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_2_0, '0', blocks_add_xx_1, '0']
- [blocks_transcendental_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_transcendental_1_0, '0', blocks_multiply_const_vxx_1_1, '0']
- [pad_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_3, '0', blocks_multiply_xx_2_0, '0']
- [virtual_source_3_0, '0', blocks_multiply_xx_2, '0']
- [virtual_source_3_1, '0', blocks_add_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
